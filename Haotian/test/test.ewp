# IAR project test.ewp, settings and files
configuration Debug (78000, debug)
  General.RTConfigPath: xxx.h
  General.GeneralDeviceSelect: Unspecified78K0 78K0 - Unspecified
  ICC78000.CCOptLevel: 1
  ICC78000.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (78000)
  as the first configuration, except:
  ICC78000.CCDefines: NDEBUG
  ICC78000.CCOptLevel: 3
