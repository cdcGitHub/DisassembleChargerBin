# IAR project test1.ewp, settings and files
configuration Debug (78000, debug)
  General.GHeapSize: 512
  General.GFarHeapSize: 4096
  General.GeneralDeviceSelect: 78F0503_30 78K0 - uPD78F0503_30
  ICC78000.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC78000.CCOptLevel: 1
  ICC78000.CCOptStrategy: 0
  A78000.ADefines: __STANDARD_MODEL__
  A78000.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk78f0503_30.xcl
  XLINK.XlinkStackSize: 1
configuration Release (78000)
  as the first configuration, except:
  General.GeneralDeviceSelect: Unspecified78K0 78K0 - Unspecified
  ICC78000.CCOptLevel: 3
  ICC78000.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk.xcl
  group (top)
    ./: main.c
